<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ewarm-adv-icf.ewp</path>
    </project>
    <batchBuild />
</workspace>
